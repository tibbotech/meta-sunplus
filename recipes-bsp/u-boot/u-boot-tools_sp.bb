# copy of meta/recipes-bsp/u-boot/u-boot-tools_2021.07.bb with
# -src instead of -common

require u-boot-sp-src.inc
require u-boot-tools.inc

PROVIDES += "u-boot-tools"
